Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: VMPM4.IFC
Time: 2024-01-12T08:48:39
Written by: SwIFC
Made in: SolidWorks 2023

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: VMPM4
In: Default Storey
Material: Wood-Concrete
